# Keil uVision project AHRS.uvproj, settings and files
target AHRS (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: TEST +hex
  c flags: Optim=3 OneElfS=1
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1 UART_BUFFERED
  c misc: --c99
  c include: C:\ti\TivaWare_C_Series-2.1.0.12573;.\Std;.\User;C:\ti\TivaWare_C_Series-2.1.0.12573\sensorlib;C:\ti\TivaWare_C_Series-2.1.0.12573\utils;C:\ti\TivaWare_C_Series-2.1.0.12573\examples\boards\ek-tm4c123gxl-boostxl-senshub;C:\ti\TivaWare_C_Series-2.1.0.12573\examples\boards\ek-tm4c123gxl-boostxl-senshub\drivers
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Startup
    ./Startup/: startup_rvmdk.S
  group User
    ./User/: main.c MPU9150.C AHRS_2010.c QuatoE.c MadgwickAHRS.c
    C:/ti/TivaWare_C_Series-2.1.0.12573/utils/: uartstdio.c
  group Libraries
    C:/ti/TivaWare_C_Series-2.1.0.12573/driverlib/rvmdk/: driverlib.lib
    C:/ti/TivaWare_C_Series-2.1.0.12573/sensorlib/rvmdk/: sensorlib.lib
  group Std
    ./Std/: include.h
    ./User/: MPU9150.H AHRS_2010.h QuatoE.h MadgwickAHRS.h
